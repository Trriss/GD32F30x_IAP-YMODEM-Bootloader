# Keil uVision project bootloader.uvprojx, settings and files
target Bootloader (6210000::V6.21::ARMCLANG)
  device: GD32F303CG GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: fromelf --bin ".\objects\bootloader.axf" --output ".\objects\bootloader.bin"
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c include: ..\Drivers\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Core
    ../Core/Src/: common.c flash_if.c main.c menu.c ymodem.c
    ../Core/Inc/: common.h flash_if.h main.h menu.h ymodem.h
  group Drivers a36plus
    ../Drivers/a36plus/: config.h usart0.h gpio.c usart0.c systick.c systick.h
  group Drivers CMSIS
    ../Drivers/CMSIS/Device/GD/GD32F30x/Source/: gd32f30x_gpio.c gd32f30x_usart.c gd32f30x_crc.c gd32f30x_fmc.c startup_gd32f30x_xd.s system_gd32f30x.c gd32f30x_rcu.c
    ../Drivers/CMSIS/Device/GD/GD32F30x/Include/: gd32f30x.h gd32f30x_gpio.h gd32f30x_usart.h
